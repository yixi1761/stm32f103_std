# Keil uVision project RTC.uvprojx, settings and files
target TIMER3 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\CMSIS;.\ST;.\USER;.\DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32
    ./ST/: startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c
  group CMSIS
    ./CMSIS/: core_cm3.c core_cm3.h
  group StdPeriph_Driver
    ./DRIVER/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c
  group USER
    ./USER/: main.c led.c delay.c usart.c rtc.c
