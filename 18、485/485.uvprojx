# Keil uVision project 485.uvprojx, settings and files
target spi (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: spi +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\STM32F10x_StdPeriph_Driver\inc;.\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CM3
    ./CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
  group STM32
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c
  group StdPeriph_Drivers
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_can.c stm32f10x_fsmc.c
  group USER
    ./USER/: main.c spi.c usart.c led.c gpio.c can.c
