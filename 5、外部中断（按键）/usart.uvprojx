# Keil uVision project usart.uvprojx, settings and files
target exti (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: exti +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\StdPeriph_Driver\inc;.\STM32F10X;.\USER;.\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./Startup/: startup_stm32f10x_hd.s
    ./STM32F10X/: system_stm32f10x.c
  group CMSIS
    ./CMSIS/: core_cm3.c
  group StdPeriph_Driver
    ./StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_usart.c
  group User
    ./USER/: main.c stm32f10x_it.c Delay.c
  group APP
    ./APP/: GPIO.c exti.c
