# Keil uVision project windowdog.uvprojx, settings and files
target wdog (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: windowdog +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\APP;.\CMSIS;.\StdPeriph_Driver\inc;.\STM32F10X;.\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./APP/: GPIO.c USART.c
    ./: wwdog.c
  group USER
    ./USER/: Delay.c main.c stm32f10x_it.c
  group CMSIS
    ./CMSIS/: core_cm3.c
  group Startup
    ./Startup/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32F10X
    ./STM32F10X/: stm32f10x.h stm32f10x_conf.h system_stm32f10x.c
